# Keil uVision project Task.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Task +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\New folder;.\Listings;.\Objects;C:\Users\minaa\AppData\Local\Arm\Packs\ARM\CMSIS;C:\Users\minaa\AppData\Local\Arm\Packs\ARM\CMSIS-Compiler;C:\Users\minaa\AppData\Local\Arm\Packs\ARM\CMSIS\6.1.0\CMSIS\Core\Include;C:\Keil_v5\ARM\ARMCLANG\include;C:\Keil_v5;C:\Users\minaa\AppData\Local\Arm\Packs\Keil\TM4C_DFP\1.1.0\Device\Source\ARM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c SysTick_Private.h STD.h UART.h GPIO_Private.h NVIC_Private.h
    C:/Users/minaa/AppData/Local/Arm/Packs/Keil/TM4C_DFP/1.1.0/Device/Source/: system_TM4C123.c
    C:/Users/minaa/AppData/Local/Arm/Packs/Keil/TM4C_DFP/1.1.0/Device/Source/ARM/: startup_TM4C123.s
